# Keil uVision project Charge57082.uvproj, settings and files
target Target 1 (MCS-51)
  device: SN8F57082 SONiX
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x3FF5) CLOCK(32000000) MODC2 DPC MDU_R515
  output: Charge57082 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Source\Core;..\Source\Device\inc;..\Source\Library;..\Source\User
  group Core
    $TC_ROOT$/../../1-Chager-Design-Project/3-Keil-Project/ReBuil57082/Source/Core/: GenericTypeDefs.h SN8F5708.H
    ../Source/Core/: Systemclk.c OPTIONS_SN8F5708.A51
  group Library
    ../Source/Library/: GPIO.c ADC.c PID.c PWM.c FILTER.c TIMER.c
  group Device
    ../Source/Device/src/: Charge.c OLED.c
  group User
    ../Source/User/: main.c
